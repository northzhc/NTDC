# Keil uVision project demo.uvproj, settings and files
target demo (MCS-51)
  device: STC8G1K08 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\APP;..\BSP;..\PUB;..\STC8G;..\MOD
  group APP
    ../APP/: App_Main.c App_GlobalValue.c
  group BSP
    ../BSP/: Bsp_Stc8gGpio.c Bsp_Stc8gTimer.c Bsp_Stc8gUart.c Bsp_Stc8gClock.c Bsp_Stc8gEeprom.c
  group STC8G
    ../STC8G/: STC8Gxx.h
  group MOD
    ../MOD/: Mod_Syn480r.c Mod_Button.c
  group PUB
    ../PUB/: Pub_Delay.c Pub_TypeDefine.h
  group NOTE
    ../NOTE/: note.txt
