# Keil uVision project demo.uvprojx, settings and files
target demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\CMSIS\DeviceSupport;..\CMSIS\CMSIS\CoreSupport;..\CMSIS\STM32F10x_StdPeriph_Driver\inc;..\CMSIS;..\APP;..\BSP;..\PUB;..\MOD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../APP/: App_Main.c
  group BSP
    ../BSP/: Bsp_Stm32Gpio.c Bsp_Stm32Timer.c Bsp_Stm32Uart.c
  group MOD
    ../MOD/: Mod_Spwm.c Mod_Motor.c
  group PUB
    ../PUB/: Pub_Delay.c Pub_MyFunction.c
  group CMSIS
    ../CMSIS/CMSIS/DeviceSupport/: system_stm32f10x.c
    ../CMSIS/CMSIS/CoreSupport/: core_cm3.c
    ../CMSIS/: stm32f10x_it.c
    ../CMSIS/CMSIS/DeviceSupport/startup/mdk/: startup_stm32f10x_md.s
  group FWLIB
    ../CMSIS/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
