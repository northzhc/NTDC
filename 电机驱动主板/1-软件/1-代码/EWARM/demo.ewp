# IAR project demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103CB ST STM32F103CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD
  ICCARM.CCIncludePath2: ..\CMSIS\CMSIS\DeviceSupport; ..\APP; ..\SYSTEM\delay; ..\SYSTEM\sys; ..\SYSTEM\usart; ..\BSP; ..\CMSIS\STM32F10x_StdPeriph_Driver\inc; ..\CMSIS; ..\PUB; ..\MOD
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../APP/: App_Main.c
  group BSP
    ../BSP/: Bsp_Stm32Gpio.c Bsp_Stm32Timer.c Bsp_Stm32Uart.c
  group CMSIS
    ../CMSIS/CMSIS/DeviceSupport/startup/iar/: startup_stm32f10x_md.s
    ../CMSIS/: stm32f10x_it.c
    ../CMSIS/CMSIS/DeviceSupport/: system_stm32f10x.c
  group FWLIB
    ../CMSIS/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group MOD
    ../MOD/: Mod_Motor.c Mod_Spwm.c
  group PUB
    ../PUB/: Pub_Delay.c Pub_MyFunction.c
